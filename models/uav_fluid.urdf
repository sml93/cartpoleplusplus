Commit message: Integrated UAV class into env

File: models/uav_fluid.urdf (robot description, URDF)
Before this commit: robot uav, 2 links, 1 joints
Links:
- link fluidLink: mass 2 -> 3
- link uavLink: mass 10 -> 1
